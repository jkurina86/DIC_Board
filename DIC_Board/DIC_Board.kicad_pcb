# Repository jkurina86/DIC_Board (continued)

## KiCad design DIC_Board/DIC_Board.kicad_pcb (continued)

Schematic: Water_Pump.kicad_sch, Water Pump

Parts:
C300: 100nF; C_0402_1005Metric; MPN GRM155R71H104ME14D
C301: 10uF; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C302: 22nF; C_0402_1005Metric; MPN GRM155R71H223KA12D
D4: STPS3L60U; D_SMB; MPN STPS3L60U
J30: 0430450200; Molex_Micro-Fit_3.0_43045-0200_2x01_P3.00mm_Horizontal; MPN 0430450200; DigiKey WM1813-ND
R301: 100k; R_0402_1005Metric; MPN CRCW0402100KFKED
R302: 1.00k; R_0402_1005Metric; MPN CRCW04021K00FKED
U30: TPS27S100APWPR; TPS27S100_Thermal_Drill0p3; MPN TPS27S100APWPR; DigiKey 296-49002-1-ND

Connections:
+12V: C300.1, C301.1, U30.8 (IN), U30.9 (IN), U30.10 (IN); also elsewhere on the board
/Pump Control/WATER_PUMP_EN: R301.1, U30.3 (EN); also elsewhere on the board
GND: C300.2, C301.2, C302.2, D4.2 (A), J30.1, R301.2, R302.1, U30.2 (GND), U30.12 (DIAG_EN), U30.15 (EP); also elsewhere on the board
unnamed: C302.1, D4.1 (K), J30.2, U30.5 (OUT), U30.6 (OUT), U30.7 (OUT)
unnamed: R302.2, U30.13 (ILIM)

Notes on the sheet:
SBE 5P: 10-18 V option 1.8 A maximum turn-on surge, approximately 0.25 s.
Pump has internal reverse-polarity diode; D4 and TPS27S100A provide turn-off clamping.
TPS27S100A: 40 V / 4 A switch R302 = 1.00 kOhm sets approximately 2.5 A limit.

Schematic: Air_Pump.kicad_sch, Air Pump

Parts:
C303: 10uF; C_1206_3216Metric; MPN CGA5L1X7R1H106K160AC
C304: 100nF; C_0402_1005Metric; MPN GRM155R71H104ME14D
C305: 22nF; C_0402_1005Metric; MPN GRM155R71H223KA12D
D3: STPS1L40ZF; D_SOD-123F; MPN STPS1L40ZF; DigiKey 497-16916-1-ND
J33: 0430450200; Molex_Micro-Fit_3.0_43045-0200_2x01_P3.00mm_Horizontal; MPN 0430450200; DigiKey WM1813-ND
R304: 100k; R_0402_1005Metric; MPN CRCW0402100KFKED
R305: 1.00k; R_0402_1005Metric; MPN CRCW04021K00FKED
U31: TPS27S100APWPR; TPS27S100_Thermal_Drill0p3; MPN TPS27S100APWPR; DigiKey 296-49002-1-ND

Connections:
+6V6: C303.1, C304.1, U31.8 (IN), U31.9 (IN), U31.10 (IN); also elsewhere on the board
/Pump Control/AIR_PUMP_EN: R304.1, U31.3 (EN); also elsewhere on the board
GND: C303.2, C304.2, C305.2, D3.2 (A), J33.1, R304.2, R305.1, U31.2 (GND), U31.12 (DIAG_EN), U31.15 (EP); also elsewhere on the board
unnamed: C305.1, D3.1 (K), J33.2, U31.5 (OUT), U31.6 (OUT), U31.7 (OUT)
unnamed: R305.2, U31.13 (ILIM)

Schematic: Acid_Pump.kicad_sch, Acid Pump

Parts:
C320: 2.2uF 16V; C_0603_1608Metric; Voltage Rating 16V; Tolerance 10%; MPN C1608X5R1C225K080AB
C321: 22uF 16V; C_1210_3225Metric; Voltage Rating 25V; Tolerance 20%; MPN GRM32ER71E226ME15L
C322: 10nF; C_0603_1608Metric; Voltage Rating 50V; Tolerance 10%; MPN C1608X7R1H103K080AA
C323: 1nF; C_0603_1608Metric; Voltage Rating 50V; Tolerance 5%; MPN C1608C0G1H102J080AA
C324: 22nF; C_0603_1608Metric; Voltage Rating 50V; Tolerance 10%; MPN C1608X7R1H223K080AA
J9: Conn_01x04; Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal; MPN 0430450400
R320, R321: 2.00R 1%; R_1206_3216Metric; Tolerance 1%; Power Rating 0.25W; MPN CRCW12062R00FKEA
R322, R323, R324, R325: 20k; R_0603_1608Metric; Tolerance 1%; Power Rating 0.125W; MPN CRCW060320K0FKEA
R326: 47k; R_0603_1608Metric; Tolerance 1%; Power Rating 0.125W; MPN CRCW060347K0FKEA
R327: 1k; R_0603_1608Metric; Tolerance 1%; Power Rating 0.125W; MPN CRCW06031K00FKEA
R328: 2.87k; R_0603_1608Metric; Tolerance 0.1%; Power Rating 0.125W; MPN TNPW06032K87BEEA
R329: 487R; R_0603_1608Metric; Tolerance 0.1%; Power Rating 0.125W; MPN TNPW0603487RBEEA
RV1: 10k trim; Potentiometer_Bourns_3314J_Vertical; MPN 3314J-1-103E
U32: STSPIN220; VQFN-16-1EP_3x3mm_P0.5mm_EP1.8x1.8mm; MPN STSPIN220

Connections:
+2V8: C320.1, C321.1, U32.6 (VS); also elsewhere on the board
+3V3: R322.1, R323.1, R324.1, R328.1, U32.15 (MODE2); also elsewhere on the board
/Pump Control/ACID_PUMP_DIR: R324.2, U32.1 (DIR); also elsewhere on the board
/Pump Control/ACID_PUMP_EN_FAULT_N: C322.1, R322.2, U32.13 (EN/FLT); also elsewhere on the board
/Pump Control/ACID_PUMP_RESET_N: C323.1, R323.2, U32.14 (STBY/RESET); also elsewhere on the board
/Pump Control/ACID_PUMP_STEP: R325.1, U32.2 (STCK); also elsewhere on the board
GND: C320.2, C321.2, C322.2, C323.2, C324.2, R320.2, R321.2, R325.2, R326.2, R329.2, U32.7 (GND), U32.16 (MODE1), U32.17 (EPAD); also elsewhere on the board
unnamed: C324.1, R327.2
unnamed: J9.1, U32.3 (OUTA1)
unnamed: J9.2, U32.5 (OUTA2)
unnamed: J9.3, U32.10 (OUTB1)
unnamed: J9.4, U32.8 (OUTB2)
unnamed: R328.2, RV1.1
unnamed: R329.1, RV1.2, RV1.3, U32.11 (REF)
unnamed: R320.1, U32.4 (SENSEA)
unnamed: R321.1, U32.9 (SENSEB)
unnamed: R326.1, R327.1, U32.12 (TOFF)

Notes on the sheet:
RESET defaults HIGH via 20k pull-up (Adafruit reference). Drive RESET low to select mode; set STEP low and DIR high, then release RESET and hold straps for at least100us.
ACID PUMP STEPPER DRIVER STSPIN220, +2V8 MOTOR SUPPLY
Tie RV1 wiper to its VREF-side terminal. Use >=0.25 W sense resistors; place them and C320/C321 close to U32.
Fixed 1/4-step latch: MODE1=0, MODE2=1, STEP=0 and DIR=1 when STBY/RESET rises.
Current limit: 2.00 ohm sense; RV1 adjusts ~0.06-0.24 A nominal. Set VREF=0.218 V (~4.0k trim) for I_PEAK~0.109 A.
Design basis: ~0.11 A provides margin over the Aquatech BD202411-T 0.1 A output. Validate the installed RP-TX winding and ramp STEP rate.

Board: 4 copper layers, 291 parts (0 on the bottom side), 216 nets, no tracks yet.

File Reviews/component-audit-2026-09-11.md (part):

# Final component audit — 11 September 2026

All282 resolved components. “Assigned” means MPN/footprint fields exist and the footprint has matching numbered pads; see the review for electrical and physical exceptions. Test points are fabricated copper features. All nets/pin mappings are in `analysis/review_20260911/final-components.json`.

## /Actuators/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C317 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C318 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C319 | 22nF | GRM155R71H223KA12D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C325 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C326 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C327 | 22nF | GRM155R71H223KA12D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| J5 | Conn_01x10 | 0430451000 | Connector_Molex:Molex_Micro-Fit_3.0_43045-1000_2x05_P3.00mm_Horizontal | Assigned |
| R312 | 15k | CRCW040215K0FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R313 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R314 | 1.00k | CRCW04021K00FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R315 | 15k | CRCW040215K0FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R316 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R317 | 1.00k | CRCW04021K00FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| U36 | TPS27S100APWPR | TPS27S100APWPR | Package_SO:Texas_HTSSOP-14-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask3.155x3.255mm_ThermalVias | Assigned |
| U37 | TPS27S100APWPR | TPS27S100APWPR | Package_SO:Texas_HTSSOP-14-1EP_4.4x5mm_P0.65mm_EP3.4x5mm_Mask3.155x3.255mm_ThermalVias | Assigned |

## /Comms/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C331 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C333 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C334 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C336 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C337 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| J11 | Conn_01x04 | 0430450400 | Connector_Molex:Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal | Assigned |
| U39 | MAX3226EETE | MAX3226EETE | Package_DFN_QFN:TQFN-16-1EP_5x5mm_P0.8mm_EP3.1x3.1mm | Assigned |

## /Comms/Aux/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C332 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C338 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C339 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C341 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C342 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| D5 | BZT52C8V2-7-F | BZT52C8V2-7-F | Diode_SMD:D_SOD-123 | Assigned |
| J12 | Conn_01x04 | 0430450400 | Connector_Molex:Molex_Micro-Fit_3.0_43045-0400_2x02_P3.00mm_Horizontal | Assigned |
| J13 | Conn_01x05_Pin | 0436500500 | Connector_Molex:Molex_Micro-Fit_3.0_43650-0500_1x05_P3.00mm_Horizontal | Assigned |
| Q1 | DMC3016LDV-13 | DMC3016LDV-13 | DIC_Board:DMT3020LDV13 | Assigned |
| R345 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R346 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R347 | 4.7k | CRCW04024K70FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| U40 | MAX3226EETE | MAX3226EETE | Package_DFN_QFN:TQFN-16-1EP_5x5mm_P0.8mm_EP3.1x3.1mm | Assigned |

## /Power/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C100 | 100uF | EEHZA1V101P | Capacitor_SMD:CP_Elec_8x10.5 | Assigned |
| C101 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| D10 | SMBJ18A | SMBJ18A | Diode_SMD:D_SMB | Assigned |
| F10 | 10A | 0451010.MRL | Fuse:Fuse_Littelfuse-NANO2-451_453 | Assigned |
| J31 | 0430450200 | 0430450200 | Connector_Molex:Molex_Micro-Fit_3.0_43045-0200_2x01_P3.00mm_Horizontal | Assigned |
| TP20 | P_IN | — | TestPoint:TestPoint_Plated_Hole_D2.0mm | Fabricated test point |
| TP21 | P_IN | — | TestPoint:TestPoint_Plated_Hole_D2.0mm | Fabricated test point |

## /Power/12V/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C102 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C103 | 100nF | GRM155R71H104ME14D | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C104 | 10nF | CGA2B3X7R1H103K050BB | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C105 | 100pF | CGA2B2C0G1H101J050BA | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C106 | 10uF | GRM31CR71E106KA12L | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C107 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C108 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C109 | 22uF | GRM32ER71E226ME15L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C110 | 22uF | GRM32ER71E226ME15L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C111 | 22uF | GRM32ER71E226ME15L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C112 | 22uF | GRM32ER71E226ME15L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C113 | 220uF | EEHZA1E221P | Capacitor_SMD:CP_Elec_8x10.5 | Assigned |
| C119 | 10nF | CGA2B3X7R1H103K050BB | Capacitor_SMD:C_0402_1005Metric | Assigned |
| C40 | 0.1uF | C1608X7R1H104K080AA | Capacitor_SMD:C_0603_1608Metric | Assigned |
| C41 | 100uF | EEHZA1V101P | Capacitor_SMD:CP_Elec_8x10.5 | Assigned |
| C42 | 0.1uF | C1608X7R1H104K080AA | Capacitor_SMD:C_0603_1608Metric | Assigned |
| L10 | 4.7uH | XAL1010-472MEB | Inductor_SMD:L_Coilcraft_XAL1010-XXX | Assigned |
| Q100 | CSD18542KTTT | CSD18542KTTT | Package_TO_SOT_SMD:TO-263-3_TabPin2 | Assigned |
| Q101 | CSD18542KTTT | CSD18542KTTT | Package_TO_SOT_SMD:TO-263-3_TabPin2 | Assigned |
| R100 | 150k | CRCW0402150KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R101 | 24.9k | CRCW040224K9FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R102 | 49.9k | CRCW040249K9FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R103 | 6.8m | WSL25126L800FEA | Resistor_SMD:R_2512_6332Metric | Assigned |
| R104 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R105 | 11.1k | CRCW040211K1FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R106 | 49.9R | CRCW040249R9FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R112 | 24.9k | CRCW040224K9FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R113 | 24.9k | CRCW040224K9FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R114 | 1R | CRCW06031R00FKEA | Resistor_SMD:R_0603_1608Metric | Assigned |
| R115 | 1R | CRCW06031R00FKEA | Resistor_SMD:R_0603_1608Metric | Assigned |
| TP22 | +12V | — | TestPoint:TestPoint_Plated_Hole_D2.0mm | Fabricated test point |
| U10 | TPS552882RPMR | TPS552882RPMR | DIC_Board:Texas_RPM0026A_TPS552882 | Assigned |

## /Power/2V8/

| Ref | Value | MPN | Footprint | Status |
|---|---|---|---|---|
| C130 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C131 | 10uF | CGA5L1X7R1H106K160AC | Capacitor_SMD:C_1206_3216Metric | Assigned |
| C133 | 47uF | GRM32ER61A476ME20L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C134 | 47uF | GRM32ER61A476ME20L | Capacitor_SMD:C_1210_3225Metric | Assigned |
| C36 | 0.1uF | C1608X7R1H104K080AA | Capacitor_SMD:C_0603_1608Metric | Assigned |
| C37 | 0.1uF | C1608X7R1H104K080AA | Capacitor_SMD:C_0603_1608Metric | Assigned |
| R123 | 10k | CRCW040210K0FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R124 | 5.56k | CRCW04025K56FKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| R20 | 100k | CRCW0402100KFKED | Resistor_SMD:R_0402_1005Metric | Assigned |
| TP26 | +2V8 | — | TestPoint:TestPoint_Plated_Hole_D2.0mm | Fabricated test point |
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